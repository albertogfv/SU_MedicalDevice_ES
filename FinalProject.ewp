# IAR project FinalProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3Sx9xx TexasInstruments LM3Sx9xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ewarm; PART_LM3S8962
  ICCARM.CCIncludePath2: ; ..; ..\..\..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: FinalProject.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: bool.c bool.h computeTask.c computeTask.h dataPtrs.c dataPtrs.h dataStructs.c delays.c delays.h displayTask.c displayTask.h main.c measureTask.c measureTask.h startup_ewarm.c statusTask.c statusTask.h systemTimeBase.c systemTimeBase.h warningAlarm.c warningAlarm.h
    ../../../driverlib/ewarm/Exe/: driverlib.a
    ../drivers/: rit128x96x4.c rit128x96x4.h
